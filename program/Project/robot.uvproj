# Keil uVision project robot.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: robot +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Headers
  group Source Group 1
    ./codes/: 20 4.c
